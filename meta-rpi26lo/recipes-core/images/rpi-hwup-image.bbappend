KERNEL_DEVICETREE = " \
    bcm2709-rpi-2-b.dtb \
    "

IMAGE_INSTALL_append = " openssh openssh-ssh openssh-sshd openssh-scp openssl-dev openssl libcrypto libssl libusb1-dev dbus-dev dbus-lib tcpdump wpan-tools"

